# Keil uVision project template.uvprojx, settings and files
target AC6-flash (6190000::V6.19::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: template
  AfterMake: .\axf2uf2.bat $K
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO
  c misc: -include env_wrapper.h -Wno-macro-redefined -Omax
  c include: ..\..\pico-sdk\src\rp2040\hardware_structs\include;..\..\pico-sdk\src\rp2_common\cmsis\include\cmsis;..\..\pico-sdk\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\pico-sdk\src\boards\include\boards;..\..\pico-sdk\src\rp2040\hardware_regs\include;.\wrapper;..\..\pico-sdk\src\rp2_common\hardware_base\include;..\..\pico-sdk\src\rp2_common\hardware_watchdog\include;..\..\pico-sdk\src\rp2_common\hardware_pll\include;..\..\pico-sdk\src\rp2_common\hardware_xosc\include;..\..\pico-sdk\src\rp2_common\hardware_flash\include\;..\..\pico-sdk\src\rp2_common\hardware_dma\include\;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\hardware_gpio\include;..\..\pico-sdk\src\rp2_common\hardware_resets\include;..\..\pico-sdk\src\rp2_common\hardware_clocks\include;..\..\pico-sdk\src\rp2_common\hardware_timer\include;..\..\pico-sdk\src\rp2_common\hardware_sync\include;..\..\pico-sdk\src\rp2_common\hardware_claim\include;..\..\pico-sdk\src\rp2_common\hardware_spi\include;..\..\pico-sdk\src\rp2_common\hardware_pwm\include;..\..\pico-sdk\src\rp2_common\hardware_i2c\include;..\..\pico-sdk\src\rp2_common\hardware_uart\include;..\..\pico-sdk\src\rp2_common\hardware_adc\include;..\..\pico-sdk\src\common\pico_base\include;..\..\pico-sdk\src\rp2_common\pico_multicore\include;..\..\pico-sdk\src\common\pico_sync\include;..\..\pico-sdk\src\common\pico_time\include;..\..\pico-sdk\src\common\pico_util\include;..\..\pico-sdk\src\common\pico_stdlib\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src;..\..\pico-sdk\src\rp2_common\pico_runtime\include;..\..\pico-sdk\src\rp2_common\pico_printf\include;..\..\pico-sdk\src\rp2_common\pico_bootrom\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src\rp2_common\pico_stdio_uart\include;..\..\pico-sdk\src\rp2_common\pico_stdio_usb\include;..\..\pico-sdk\src\common\pico_binary_info\include;..\..\pico-sdk\src\rp2_common\pico_stdio_semihosting\include;..\mdk;..\..\pico-sdk\src\rp2_common\pico_bootrom\include;..\..\pico-sdk\src\rp2_common\pico_double\include;..\..\pico-sdk\src\rp2_common\hardware_divider\include;..\..\pico-sdk\src\rp2_common\pico_rand\include;..\..\pico-sdk\src\rp2_common\pico_unique_id\include;..\..\bsp;..\..\lvgl-8.3.9
  asm define: PICO_MAX_SHARED_IRQ_HANDLERS=4,LIB_CMSIS_CORE=1,PICO_CMSIS_RENAME_EXCEPTIONS=1
  asm include: ..\..\pico-sdk\src\rp2040\hardware_regs\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\pico_platform\include;..\..\pico-sdk\src\common\pico_base\include;.\wrapper\pico_base;..\..\pico-sdk\src\rp2_common\boot_stage2\asminclude;..\..\pico-sdk\src\rp2_common\boot_stage2\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329 --keep=compile_time_choice.o --entry=_stage2_boot
--keep=ram_vector_table
  group Pico-SDK
    ./: startup_RP2040.c
    ../../pico-sdk/src/rp2_common/cmsis/stub/CMSIS/Device/RaspberryPi/RP2040/Source/: system_RP2040.c
    ../../pico-sdk/src/rp2_common/hardware_clocks/: clocks.c
    ../../pico-sdk/src/rp2_common/hardware_watchdog/: watchdog.c
    ../../pico-sdk/src/rp2_common/hardware_pll/: pll.c
    ../../pico-sdk/src/rp2_common/pico_platform/: platform.c
    ../../pico-sdk/src/rp2_common/hardware_xosc/: xosc.c
    ../../pico-sdk/src/rp2_common/hardware_irq/: irq.c irq_handler_chain.S
    ../../pico-sdk/src/rp2_common/hardware_gpio/: gpio.c
    ../../pico-sdk/src/rp2_common/pico_multicore/: multicore.c
    ../../pico-sdk/src/rp2_common/hardware_sync/: sync.c
    ../../pico-sdk/src/common/pico_sync/: critical_section.c lock_core.c mutex.c sem.c
    ../../pico-sdk/src/common/pico_time/: time.c timeout_helper.c
    ../../pico-sdk/src/rp2_common/hardware_timer/: timer.c
    ../../pico-sdk/src/rp2_common/hardware_claim/: claim.c
    ../../pico-sdk/src/common/pico_util/: queue.c pheap.c datetime.c
    ../../pico-sdk/src/host/pico_stdlib/: stdlib.c
    ../../pico-sdk/src/rp2_common/hardware_uart/: uart.c
    ../../pico-sdk/src/rp2_common/boot_stage2/: compile_time_choice.S boot2_w25q080.S
    ./wrapper/: runtime.c
    ../../pico-sdk/src/rp2_common/pico_printf/: printf_none.S
    ../../pico-sdk/src/rp2_common/hardware_i2c/: i2c.c
    ../../pico-sdk/src/rp2_common/hardware_spi/: spi.c
    ../../pico-sdk/src/rp2_common/hardware_adc/: adc.c
    ../../pico-sdk/src/rp2_common/pico_bootrom/: bootrom.c
    ../../pico-sdk/src/rp2_common/pico_stdio_uart/: stdio_uart.c
    ../../pico-sdk/src/rp2_common/pico_standard_link/: binary_info.c
    ../../pico-sdk/src/rp2_common/hardware_flash/: flash.c
    ../../pico-sdk/src/rp2_common/hardware_dma/: dma.c
    ../../pico-sdk/src/rp2_common/hardware_divider/: divider.S
  group platform
    ./wrapper/: env_wrapper.h env_wrapper.c stdio.c
    ./wrapper/pico/: platform.h
    ./wrapper/hardware/: sync.h
  group Application
    ../../: main.c
  group BSP
    ../../bsp/: bsp_led.c bsp_spilcd.c
  group lvgl\core
    ../../lvgl-8.3.9/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl\draw
    ../../lvgl-8.3.9/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../lvgl-8.3.9/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl\extra
    ../../lvgl-8.3.9/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../lvgl-8.3.9/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../lvgl-8.3.9/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../lvgl-8.3.9/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../lvgl-8.3.9/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../lvgl-8.3.9/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../lvgl-8.3.9/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../lvgl-8.3.9/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../lvgl-8.3.9/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../lvgl-8.3.9/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../lvgl-8.3.9/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../lvgl-8.3.9/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/led/: lv_led.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/list/: lv_list.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/span/: lv_span.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../lvgl-8.3.9/lvgl/src/extra/widgets/win/: lv_win.c
    ../../lvgl-8.3.9/lvgl/src/extra/: lv_extra.c
  group lvgl\font
    ../../lvgl-8.3.9/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl\hal
    ../../lvgl-8.3.9/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl\misc
    ../../lvgl-8.3.9/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl\widgets
    ../../lvgl-8.3.9/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl\porting
    ../../lvgl-8.3.9/lvgl/examples/porting/: lv_port_disp.c
  group lvgl\demos
    ../../lvgl-8.3.9/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../../lvgl-8.3.9/lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
target AC6-RunInSRAM (6190000::V6.19::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: template
  AfterMake: .\axf2uf2.bat
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO,__PICO_USE_LCD_1IN3__=0
  c misc: -include env_wrapper.h  -Wno-macro-redefined
  c include: ..\..\pico-sdk\src\rp2_common\hardware_flash\include\;..\..\pico-sdk\src\rp2_common\hardware_dma\include\;..\..\pico-sdk\src\rp2040\hardware_structs\include;..\..\pico-sdk\src\rp2_common\cmsis\include\cmsis;..\..\pico-sdk\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\pico-sdk\src\boards\include\boards;..\..\pico-sdk\src\rp2040\hardware_regs\include;.\wrapper;..\..\pico-sdk\src\rp2_common\hardware_base\include;..\..\pico-sdk\src\rp2_common\hardware_watchdog\include;..\..\pico-sdk\src\rp2_common\hardware_pll\include;..\..\pico-sdk\src\rp2_common\hardware_xosc\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\hardware_gpio\include;..\..\pico-sdk\src\rp2_common\hardware_resets\include;..\..\pico-sdk\src\rp2_common\hardware_clocks\include;..\..\pico-sdk\src\rp2_common\hardware_timer\include;..\..\pico-sdk\src\rp2_common\hardware_sync\include;..\..\pico-sdk\src\rp2_common\hardware_claim\include;..\..\pico-sdk\src\rp2_common\hardware_spi\include;..\..\pico-sdk\src\rp2_common\hardware_pwm\include;..\..\pico-sdk\src\rp2_common\hardware_i2c\include;..\..\pico-sdk\src\rp2_common\hardware_uart\include;..\..\pico-sdk\src\rp2_common\hardware_adc\include;..\..\pico-sdk\src\common\pico_base\include;..\..\pico-sdk\src\rp2_common\pico_multicore\include;..\..\pico-sdk\src\common\pico_sync\include;..\..\pico-sdk\src\common\pico_time\include;..\..\pico-sdk\src\common\pico_util\include;..\..\pico-sdk\src\common\pico_stdlib\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src;..\..\pico-sdk\src\rp2_common\pico_runtime\include;..\..\pico-sdk\src\rp2_common\pico_printf\include;..\..\pico-sdk\src\rp2_common\pico_bootrom\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src\rp2_common\pico_stdio_uart\include;..\..\pico-sdk\src\rp2_common\pico_stdio_usb\include;..\..\pico-sdk\src\common\pico_binary_info\include;..\..\pico-sdk\src\rp2_common\pico_stdio_semihosting\include;..\..\bsp\Config;..\..\bsp\LCD;..\..\bsp;..\mdk
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040_run_in_sram.sct
  link misc: as above
target AC6-DebugInSRAM (6190000::V6.19::ARMCLANG)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: template
  AfterMake: .\axf2uf2.bat
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: PICO, NDEBUG, PICO_NO_FLASH, __PICO_USE_LCD_1IN3__=0
  c misc: -include env_wrapper.h  -Wno-macro-redefined -Omax
  c include: ..\..\pico-sdk\src\rp2_common\hardware_flash\include\;..\..\pico-sdk\src\rp2_common\hardware_dma\include\;..\..\pico-sdk\src\rp2040\hardware_structs\include;..\..\pico-sdk\src\rp2_common\cmsis\include\cmsis;..\..\pico-sdk\src\rp2_common\cmsis\stub\CMSIS\Device\RaspberryPi\RP2040\Include;..\..\pico-sdk\src\boards\include\boards;..\..\pico-sdk\src\rp2040\hardware_regs\include;.\wrapper;..\..\pico-sdk\src\rp2_common\hardware_base\include;..\..\pico-sdk\src\rp2_common\hardware_watchdog\include;..\..\pico-sdk\src\rp2_common\hardware_pll\include;..\..\pico-sdk\src\rp2_common\hardware_xosc\include;..\..\pico-sdk\src\rp2_common\hardware_irq\include;..\..\pico-sdk\src\rp2_common\hardware_gpio\include;..\..\pico-sdk\src\rp2_common\hardware_resets\include;..\..\pico-sdk\src\rp2_common\hardware_clocks\include;..\..\pico-sdk\src\rp2_common\hardware_timer\include;..\..\pico-sdk\src\rp2_common\hardware_sync\include;..\..\pico-sdk\src\rp2_common\hardware_claim\include;..\..\pico-sdk\src\rp2_common\hardware_spi\include;..\..\pico-sdk\src\rp2_common\hardware_pwm\include;..\..\pico-sdk\src\rp2_common\hardware_i2c\include;..\..\pico-sdk\src\rp2_common\hardware_uart\include;..\..\pico-sdk\src\rp2_common\hardware_adc\include;..\..\pico-sdk\src\common\pico_base\include;..\..\pico-sdk\src\rp2_common\pico_multicore\include;..\..\pico-sdk\src\common\pico_sync\include;..\..\pico-sdk\src\common\pico_time\include;..\..\pico-sdk\src\common\pico_util\include;..\..\pico-sdk\src\common\pico_stdlib\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src;..\..\pico-sdk\src\rp2_common\pico_runtime\include;..\..\pico-sdk\src\rp2_common\pico_printf\include;..\..\pico-sdk\src\rp2_common\pico_bootrom\include;..\..\pico-sdk\src\rp2_common\pico_stdio\include;..\..\pico-sdk\src\rp2_common\pico_stdio_uart\include;..\..\pico-sdk\src\rp2_common\pico_stdio_usb\include;..\..\pico-sdk\src\common\pico_binary_info\include;..\..\pico-sdk\src\rp2_common\pico_stdio_semihosting\include;..\..\pico-sdk\src\rp2_common\boot_stage2\include;.\wrapper\pico_base;..\..\bsp\Config;..\..\bsp\LCD;..\..\bsp;..\mdk
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RP2040_debug_in_sram.sct
  link misc: --diag_suppress=L6170,L6314,L6306,L6329 --entry=Reset_Handler
software components: CMSIS:CORE 5.6.0, Utilities:perf_counter:Core 2.2.2, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
